# Keil uVision project CLOCK88.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: CLOCK88 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil\C51\INC;C:\Keil\C51\INC\STC
  group Source Group 1
    ./: STARTUP.A51 ds1302.C main.c LEDMatrix.c adc.c cli.c var.c CONF_TNY.A51 uart.c
